<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\GPIO_READ_IT\read_it.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tm1637.ewp</path>
    </project>
    <batchBuild />
</workspace>

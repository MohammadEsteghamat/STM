# IAR project ee.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\my_GitHub\STM8\eeprom_external; E:\STM8_LIBRARY\inc; E:\STM8_LIBRARY\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ee.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c tm1637.c tm1637.h tm1637_config.h
    ../../../STM8_LIBRARY/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c
    ../../../STM8_LIBRARY/inc/: stm8s_clk.h stm8s_flash.h stm8s_gpio.h

# IAR project remut.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\Acer\Desktop\STM8\REMUT_RXB61; C:\Users\Acer\Desktop\st8\inc; C:\Users\Acer\Desktop\st8\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: remut.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_it.c stm8s_it.h
    ../../st8/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
    ../../st8/inc/: stm8s_clk.h stm8s_gpio.h stm8s_tim1.h stm8s_tim2.h stm8s_uart1.h

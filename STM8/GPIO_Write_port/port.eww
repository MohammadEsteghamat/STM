<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\blink\blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\port.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\GPIO_READ\read.ewp</path>
    </project>
    <batchBuild />
</workspace>
